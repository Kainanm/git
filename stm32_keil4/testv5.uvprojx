# Keil uVision project testv5.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: testv5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, ARM_MATH_CM7, ARM_MATH_CM4, ARM_MATH_CM3, ARM_MATH_CM0PLUS, ARM_MATH_CM0, ARM_MATH_ARMV8MBL, ARM_MATH_ARMV8MML
  c include: .\Resp;.\Resp\arm_fft_bin_example;.\Resp\arm_fir_example;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\JOYPAD;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\USMART;.\Resp\Include;.\Exti\HARDWARE\BEEP;.\Exti\HARDWARE\EXTI;.\Exti\HARDWARE\KEY;.\Exti\HARDWARE\LED;.\Exti\SYSTEM\delay;.\Exti\SYSTEM\sys;.\Exti\SYSTEM\usart;.\Resp\arm_fft_bin_example\Include;.\Resp\arm_fir_example\Include;.\HARDWARE\WDG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0xecccd008 size 0xecccffff
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c STM32F10x.s
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/LCD/: ILI93xx.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/MPU6050/: mpuiic.c mpu6050.c
    ./HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Exti/HARDWARE/EXTI/: exti.c
    ./HARDWARE/WDG/: wdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group USMART
    ./USMART/: usmart.c usmart_config.c usmart_str.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Compiler:I/O:STDIN 1.4.0, Compiler:I/O:STDOUT 1.4.0
